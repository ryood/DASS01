# Repository ryood/DASS01

## EAGLE design eagle/+-12V_PSU/+-12V_PSU.brd

Parts:
C1, C2: 100uF; E2,5-7
C3, C4: 470uF; E7,5-16
C5, C6: 0.33uF; C025-024X044
C7, C8: 0.1uF; C025-024X044
CN1: OUT; 03PA
D1, D2, D3, D4: 1S4; DO35-7
IC1: 7812T; TO220H
IC2: 7912; TO220H
JP1: TP_GND; 1X02
L1, L2: CM Choke; EV20
LED1: RED; LED3MM
LED2: Blue; LED3MM
R1, R2: 1k; 0207/7
SL1: IN; 03PA

Connections:
+12V: C3.+, C7.1, CN1.1, D1.A, D3.C, IC1.3 (VO), R1.2
+15V: C1.+, C5.1, D1.C, IC1.1 (VI), L1.4
-12V: C4.-, C8.2, CN1.3, D2.C, D4.A, IC2.3 (VO), R2.1
-15V: C2.-, C6.2, D2.A, IC2.2 (VI), L2.2
GND: C1.-, C2.+, C3.-, C4.+, C5.2, C6.1, C7.2, C8.1, CN1.2, D3.A, D4.C, IC1.2 (GND), IC2.1 (GND), JP1.1, JP1.2, L1.2, L2.4, LED1.K (C), LED2.A
unnamed: L1.1, L2.3, SL1.2
unnamed: L2.1, SL1.1
unnamed: LED2.K (C), R2.2
unnamed: LED1.A, R1.1
unnamed: L1.3, SL1.3

Board: 2 copper layers, 93.7 x 71.1 mm, 23 parts (0 on the bottom side), 10 nets.

## EAGLE design eagle/DASS01_CV_Amp/DASS01_CV_Amp.brd

Parts:
C1, C2: 47uF; E2,5-7
C3, C4: 0.1uF; C025-024X044
CN1: PWR_IN; B3B-XH-A
CN2, CN3, CN4: PWR_OUT; B3B-XH-A
IC1: NJM4580; DIL08
JP1: CV_IN1; 1X02
JP2: CV_OUT1; 1X02
JP3: CV_IN2; 1X02
JP4: CV_OUT2; 1X02
JP5: TP_GND; 1X02
LED1: RED; LED3MM
LED2: BLUE; LED3MM
R1, R3: 20k; 0207/7
R2, R4: 10k; 0207/7
R5, R6: 47; 0207/7
R7, R8: 1k; 0207/7

Connections:
+9V: C1.+, C3.1, CN1.1, CN2.1, CN3.1, CN4.1, IC1.8 (V+), R7.2
-9V: C2.-, C4.2, CN1.3, CN2.3, CN3.3, CN4.3, IC1.4 (V-), R8.1
GND: C1.-, C2.+, C3.2, C4.1, CN1.2, CN2.2, CN3.2, CN4.2, JP1.2, JP2.2, JP3.2, JP4.2, JP5.1, JP5.2, LED1.K (C), LED2.A, R2.2, R4.2
unnamed: IC1.2 (-IN), R1.1, R2.1
unnamed: IC1.1 (OUT), R1.2, R5.1
unnamed: IC1.3 (+IN), JP1.1
unnamed: IC1.6 (-IN), R3.1, R4.1
unnamed: IC1.7 (OUT), R3.2, R6.1
unnamed: IC1.5 (+IN), JP3.1
unnamed: JP2.1, R5.2
unnamed: JP4.1, R6.2
unnamed: LED2.K (C), R8.2
unnamed: LED1.A, R7.1

Notes on the sheet:
R1はピンソケットで実装
R３はピンソケットで実装

Board: 2 copper layers, 71.1 x 45.7 mm, 24 parts (0 on the bottom side), 13 nets.

## Commit log

2019-02-12 Add: +-12V_PSU eagle files
2019-02-16 +-12V_PSU Soldering Complete
2019-03-04 Add: +-12V_PSUテスト表
2019-04-14 Add: DASS01ブロック図
